# fix compile error
DEPENDS:append = " cups"

