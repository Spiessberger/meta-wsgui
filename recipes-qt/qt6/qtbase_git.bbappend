PACKAGECONFIG:append = " sql-sqlite"

